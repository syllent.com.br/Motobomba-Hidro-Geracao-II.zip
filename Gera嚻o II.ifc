Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [ContentGUID: 79fc7846-b8bd-4a55-b49c-b72764612d86, VersionGUID: 247708c4-50f0-4e68-9cd3-de1040eea795, NumberOfSaves: 1], CoordinateReference [CoordinateBase: Coordenadas compartilhadas, ProjectSite: Terreno padrão]
File name: Geração II.ifc
Time: 2025-02-02T14:52:30-03:00
Author: Marcilio Henrique M. Santos, eng.henrique@outlook.com
Organization: Map Projetos Inteligentes
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.0.13 (PTB) - IFC 24.3.0.13

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm (6)
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: 349; Tipo: Cabeça de 8 mm
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no
Outros(Tipo) - Categoria: Níveis; Nome da família: Nível
Restrições(Tipo) - Base da elevação: Ponto base do projeto
Gráficos(Tipo) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Dados de identidade(Tipo) - Nome do tipo: Cabeça de 8 mm
Name | LongName = Nome | Elevation (mm) = Elevação (mm)
Sapata B.O. | Sapata B.O. | -4600
Sapata T.O. | Sapata T.O. | -4300
Laje T.O. | Laje T.O. | -4000
Parede da fundação T.O. | Parede da fundação T.O. | -300
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 4000

# IfcBuildingElementProxy: Geração II:1/2cv - 220v, Geração II:1/2cv - 220v:307152
In: Nível 1
Type - Material: Plástico prego - Syllent, Aço Inox, Plástico azul - Syllet, <Unnamed>
Type - Outros - Categoria: Equipamento mecânico; Nome da família: Geração II
Type - Restrições - Elevação padrão: 0 mm
Type - Dados - Tabela: Geração II
Type - Cotas - DN - Recalque: 32 mm; DN - Sucção: 40 mm; l1: 5 mm; l2: 71 mm; m: 4 mm; Raio 1: 7 mm
Type - Geral - Data de criação: Dezembro de 2024; e-mail de contato:: eng.henrique@outlook.com; Família produzida por:: Marcilio Henrique M. Santos
Type - Dados de identidade - Descrição: Motobomba Geração II MB63E0115 A/P 1/2cv Monofásica 220v; Fabricante: Syllent; Modelo: MB63E0115 A/P; Nome do tipo: 1/2cv - 220v; Número OmniClass: 23.60.30.21.17; Título OmniClass: Motor Pumps; URL: https://www.syllent.com.br/produto-bomba-gii-hidromassagem
Type - Materiais e acabamentos - Carenagem: Plástico prego - Syllent; Tampa frontal: Plástico azul - Syllet
Type - Mecânica - Classificação: Bomba
Type - Pset_ManufacturerTypeInformation - Manufacturer: Syllent
Pset_BuildingElementProxyCommon - Reference: Geração II:1/2cv - 220v; sets with these values: 2
Quantidade de equipamento mecânico - Descrição da unidade: Geração II; Tipo: 1/2cv - 220v; Descrição: Motobomba Geração II MB63E0115 A/P 1/2cv Monofásica 220v; Fabricante: Syllent; Modelo: MB63E0115 A/P; URL: https://www.syllent.com.br/produto-bomba-gii-hidromassagem
Outros - Família: Geração II; Família e tipo: Geração II: 1/2cv - 220v; ID de tipo: 307132; Tipo: 1/2cv - 220v
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível 1
Cotas - Área: 0.142215 m2; Volume: 0.00245926 m3
Dados de identidade - Corrente: 3.4 A; Descrição do Material: Motobomba Geração II MB63E0115 A/P 1/2cv Monofásica 220v; Fator de potência: 0.98; Marca: 2; Peso: 3.94 kg; Potência: 370 W; Pressão máx. na sucção: 40000 Pa; Pressão máxima: 125000 Pa; Proteção: IP 65; Temperatura máx. da água: 45 C; Temperatura mín. da água: 5 C; Tensão: 220 V; Vazão máxima: 3.61111 dm3/s
Mecânica - Classificação do sistema: Não definido
Fases - Fase criada: Fase 1

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
InPort_307152_1 | SINK
OutPort_307152_2 | SOURCE
